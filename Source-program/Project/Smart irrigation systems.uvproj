# Keil uVision project Smart irrigation systems.uvproj, settings and files
target Smart irrigation systems (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Smart-irrigation-systems +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Code\DeveloperCode\inc;..\Code\DirverCode\inc;..\Code\Public\inc
  group Public
    ../Code/Public/inc/: INCLUDES.H
    ../Code/Public/: MAIN.C PBDATA.C TIME_BASE.C
  group DirverCode
    ../Code/DirverCode/: I2C.C PCF8591.C LCD1602.C Timer_Clock.C
  group DeveloperCode
    ../Code/DeveloperCode/: SeparateDis.C Unknown_Category.C SysSelf-test_And_SysInit.C Key_WorkMode_DisControl.C
